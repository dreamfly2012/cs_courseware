	ORG 0000H
START:	MOV R6,#4
	MOV R7,#9
	MOV A,R6
	MOV B,#10
	MUL AB
	ADD A,R7
           	MOV R6,A
           	RR A
           	RR A
           	RR A 
           	RR A
	ANL A,#0FH
	MOV R7,A
	MOV DPTR,#0FF21H
 	MOV A,02H
         	MOVX @DPTR,A
	MOV DPTR,#SEG
	MOV A,R7
	MOVC A,@A+DPTR
	MOV DPTR,#0FF22H
	MOVX @DPTR,A

	MOV A,#255
L1:	DEC A
	JNZ L1

	MOV A,#0FFH
	MOV DPTR,#0FF22H
	MOVX @DPTR,A

        MOV A,R6
        ANL A,#0FH
    	MOV R7,A
	MOV DPTR,#0FF21H
	MOV A,01H
	MOVX @DPTR,A      	
	MOV A,R7
	MOV DPTR,#SEG
	MOVC A,@A+DPTR
	MOV DPTR,#0FF22H
	MOVX @DPTR,A



	MOV A,#0FFH
	MOV DPTR,#0FF22H
	MOVX @DPTR,A

LJMP 	START
SEG:    DB 0C0H,0F9H,0ACH,0B0H,99H,92H,82H,0F8H,80H,90H,88H,83H,0C6H,0A1H,86H,8EH
	END��