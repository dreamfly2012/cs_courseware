ORG    	0000H
LJMP  	STRT
ORG  	 000BH
CJNE  	R0,#0,LP2
LJMP 	LP1
ORG  	0040H
STRT:  	MOV 00H,#0
	
	MOV TMOD,#01H
	MOV TH0,#9EH
	MOV TL0,#57H
	MOV R2,#96
	MOV R3,#00H
	MOV R4,#0
	SETB EA
	SETB ET0
	SETB TR0
HALT:	SJMP $

LP1:	INC R4
	CJNE R4,#5,LP7
	MOV R4,#0
	SJMP LP8
LP7:	RETI
LP8:	MOV DPTR,#TAB
	MOV A,R3
	MOVC A,@A+DPTR
	CJNE A,#00H,LP0
	MOV R3,#0
	MOV A,R3
	MOV P1,A
	SJMP LP5
LP0: 	MOV P1,A
	INC R3
LP5:	DJNZ R2,LP3

	MOV R0,#1
	MOV R3,#00H

	MOV TH0,#0C2H
	MOV TL0,#0F6H
	RETI
LP3:	MOV TH0,9EH
	MOV TL0,57H
	RETI

LP2:	MOV DPTR,#TAB2
	MOV A,R3
	MOVC A,@A+DPTR
	CJNE A,#00H,LP4
	MOV R3,#00H
	MOV A,R3
	MOV P1,A
	SJMP LP6
LP4:	MOV P1,A
	INC R3
LP6:	MOV TH0,#0C2H
	MOV TL0,#0F6H
	RETI

TAB:	DB 01H,02H,04H,08H,00H
TAB2:	DB 08H,04H,02H,01H,00H
	END
